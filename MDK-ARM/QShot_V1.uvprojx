# Keil uVision project QShot_V1.uvprojx, settings and files
target QShot_V1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: QShot_V1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;D:/STM32Cube_FW_F4_V1.28.3/Drivers/STM32F4xx_HAL_Driver/Inc;D:/STM32Cube_FW_F4_V1.28.3/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;D:/STM32Cube_FW_F4_V1.28.3/Drivers/CMSIS/Device/ST/STM32F4xx/Include;D:/STM32Cube_FW_F4_V1.28.3/Drivers/CMSIS/Include;../APP;../My_Driver;../User;../FOC_Core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../User/: USER_Interrupt.c CommonDefine.h
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    D:/STM32Cube_FW_F4_V1.28.3/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group FOC_Core
    ../FOC_Core/: FOC_Math.c FOC_Math.h FOC_Transforms.c FOC_Transforms.h FOC_Svpwm.c FOC_Svpwm.h FOC_PID.c FOC_PID.h FOC_Observer.c FOC_Observer.h FOC_Qformat.h FOC_Core.c FOC_Core.h
  group APP
    ../APP/: APP_Interface.c APP_Interface.h APP_Control.c APP_Control.h APP_Protect.c APP_Protect.h APP_Params.h
  group My_Driver
    ../My_Driver/: My_GateDriver.c My_GateDriver.h My_Encoder.c My_Encoder.h My_Driver.h
software components: CMSIS:CORE 4.3.0
